## devices/Kconfig
```kconfig
menu "Device drivers"

config ENABLE_UART
    bool "Enable UART device"
    default y

endmenu
```
